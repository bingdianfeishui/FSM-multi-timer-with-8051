# Keil uVision project MultiTimerClock.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC90C58AD STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0x7FFF) CLOCK(45000000) MODP2
  output: MultiTimerClock +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\lib\lib
  group New Group
    ./src/: key.c main.c Display595.c ISP.c
    ../lib/lib/: Delay.c DS1302.c STC_eeprom.c
