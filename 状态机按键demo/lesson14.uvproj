# Keil uVision project lesson14.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC90C58RD+ STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x7FFF) CLOCK(45000000) MODP2
  output: lesson10 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\lib;C:\Keil\C51\INC
  group Source Group 1
    ../lib/: Delay.c DS1302.c
    ./src/: Display.c key.c lesson10_2.c
